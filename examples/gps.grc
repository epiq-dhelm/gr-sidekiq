options:
  parameters:
    generate_options: qt_gui
    id: gps
    output_language: python
    title: gps
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: sidekiq_nmea_0
  id: sidekiq_nmea
  parameters:
    port: /dev/ttySKIQ_UART1
  states: {}

connections:
- [sidekiq_nmea_0, out_txt, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.3.0
