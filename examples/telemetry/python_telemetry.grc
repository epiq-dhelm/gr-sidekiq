options:
  parameters:
    generate_options: qt_gui
    id: python_telemetry
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("temp")
    period: '1000'
  states: {}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("imu")
    period: '1000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import ctypes
      import os

      #Load the C shared library

      filename = 'python_telemetry_epy_block_0.py'
      so_path = os.path.abspath(os.path.join( os.path.dirname(filename), 'skiq.so'))
      skiq = ctypes.CDLL(so_path)



      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, card=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Python Telemetry',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.card = card
              self.selectPortName = 'temp'
              self.message_port_register_in(pmt.intern(self.selectPortName))
              self.set_msg_handler(pmt.intern(self.selectPortName), self.handle_temp_msg)

              self.selectPortName = 'imu'
              self.message_port_register_in(pmt.intern(self.selectPortName))
              self.set_msg_handler(pmt.intern(self.selectPortName), self.handle_imu_msg)
              self.first = True
             

          def handle_temp_msg(self, msg):
              print("in handle_temp_msg")
              temp = ctypes.c_int()

              skiq.get_temp(ctypes.byref(temp))

              print(temp.value)

          def handle_imu_msg(self, msg):
              print("in handle_imu_msg")

          def work(self, input_items, output_items):
              if self.first == True:
                  c_card = ctypes.c_byte(self.card)
                  skiq.init_card(c_card)
                  self.first = False
              output_items[0][:] = input_items[0] 
              return len(output_items[0])
    card: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_0, temp]
- [blocks_message_strobe_1, strobe, epy_block_0, imu]
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
