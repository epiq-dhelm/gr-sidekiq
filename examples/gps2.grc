options:
  parameters:
    generate_options: qt_gui
    id: gps2
    output_language: python
    title: gps2
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: sidekiq_nema_0
  id: sidekiq_nema
  parameters:
    port: /dev/ttySKIQ_UART1
  states: {}

connections:
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']
- [sidekiq_nema_0, '0', blocks_throttle_0, '0']
- [sidekiq_nema_0, out_txt, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.3.0
